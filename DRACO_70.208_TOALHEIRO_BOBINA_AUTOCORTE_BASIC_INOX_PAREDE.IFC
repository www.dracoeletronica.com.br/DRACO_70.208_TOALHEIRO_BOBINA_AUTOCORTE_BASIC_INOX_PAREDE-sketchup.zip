Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.208_TOALHEIRO_BOBINA_AUTOCORTE_BASIC_INOX_PAREDE.IFC
Time: 2023-05-19T13:42:47
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
